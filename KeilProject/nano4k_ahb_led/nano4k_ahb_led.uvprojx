# Keil uVision project nano4k_ahb_led.uvprojx, settings and files
target nano4k_ahb_led (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: nano4k_ahb_led
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o nano4k_ahb_led.bin .\Objects\nano4k_ahb_led.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CORE;.\PERIPHERAL\Includes;.\SYSTEM;.\USER
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CORE
    ./CORE/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h
  group STARTUP
    ./STARTUP/: startup_gw1ns4c.s
  group SYSTEM
    ./SYSTEM/: system_gw1ns4c.c gw1ns4c.h system_gw1ns4c.h
  group PERIPHERAL
    ./PERIPHERAL/Sources/: gw1ns4c_gpio.c gw1ns4c_i2c.c gw1ns4c_misc.c gw1ns4c_rtc.c gw1ns4c_spi.c gw1ns4c_syscon.c gw1ns4c_timer.c gw1ns4c_uart.c gw1ns4c_wdog.c
    ./PERIPHERAL/Includes/: gw1ns4c_gpio.h gw1ns4c_i2c.h gw1ns4c_misc.h gw1ns4c_rtc.h gw1ns4c_spi.h gw1ns4c_syscon.h gw1ns4c_timer.h gw1ns4c_uart.h gw1ns4c_wdog.h
  group USER
    ./USER/: main.c ahb_led.c ahb_led.h
